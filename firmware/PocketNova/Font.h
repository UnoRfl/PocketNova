#pragma once
// =====================================================================
//  Font.h — a tiny 3x5 pixel font for scrolling text
// =====================================================================
//  Each glyph is 15 characters: 5 rows of 3, top to bottom. '#' = on.
//  Draw your own letters by editing the strings!
// =====================================================================

const char* const FONT_DIGITS[10] = {
  "###" "#.#" "#.#" "#.#" "###",  // 0
  ".#." "##." ".#." ".#." "###",  // 1
  "###" "..#" "###" "#.." "###",  // 2
  "###" "..#" ".##" "..#" "###",  // 3
  "#.#" "#.#" "###" "..#" "..#",  // 4
  "###" "#.." "###" "..#" "###",  // 5
  "###" "#.." "###" "#.#" "###",  // 6
  "###" "..#" ".#." ".#." ".#.",  // 7
  "###" "#.#" "###" "#.#" "###",  // 8
  "###" "#.#" "###" "..#" "###",  // 9
};

const char* const FONT_ALPHA[26] = {
  ".#." "#.#" "###" "#.#" "#.#",  // A
  "##." "#.#" "##." "#.#" "##.",  // B
  ".##" "#.." "#.." "#.." ".##",  // C
  "##." "#.#" "#.#" "#.#" "##.",  // D
  "###" "#.." "##." "#.." "###",  // E
  "###" "#.." "##." "#.." "#..",  // F
  ".##" "#.." "#.#" "#.#" ".##",  // G
  "#.#" "#.#" "###" "#.#" "#.#",  // H
  "###" ".#." ".#." ".#." "###",  // I
  "..#" "..#" "..#" "#.#" ".#.",  // J
  "#.#" "#.#" "##." "#.#" "#.#",  // K
  "#.." "#.." "#.." "#.." "###",  // L
  "#.#" "###" "###" "#.#" "#.#",  // M
  "##." "#.#" "#.#" "#.#" "#.#",  // N
  ".#." "#.#" "#.#" "#.#" ".#.",  // O
  "##." "#.#" "##." "#.." "#..",  // P
  ".#." "#.#" "#.#" "##." ".##",  // Q
  "##." "#.#" "##." "#.#" "#.#",  // R
  ".##" "#.." ".#." "..#" "##.",  // S
  "###" ".#." ".#." ".#." ".#.",  // T
  "#.#" "#.#" "#.#" "#.#" "###",  // U
  "#.#" "#.#" "#.#" "#.#" ".#.",  // V
  "#.#" "#.#" "###" "###" "#.#",  // W
  "#.#" "#.#" ".#." "#.#" "#.#",  // X
  "#.#" "#.#" ".#." ".#." ".#.",  // Y
  "###" "..#" ".#." "#.." "###",  // Z
};

const char GLYPH_PLUS[]  = "..." ".#." "###" ".#." "...";
const char GLYPH_MINUS[] = "..." "..." "###" "..." "...";
const char GLYPH_BANG[]  = ".#." ".#." ".#." "..." ".#.";
const char GLYPH_DOT[]   = "..." "..." "..." "..." ".#.";
const char GLYPH_COLON[] = "..." ".#." "..." ".#." "...";
const char GLYPH_QUEST[] = "##." "..#" ".#." "..." ".#.";
const char GLYPH_SLASH[] = "..#" "..#" ".#." "#.." "#..";

// Returns the glyph for a character, or nullptr for space/unknown.
const char* glyphFor(char c) {
  if (c >= '0' && c <= '9') return FONT_DIGITS[c - '0'];
  if (c >= 'a' && c <= 'z') c -= 32;               // lower -> upper case
  if (c >= 'A' && c <= 'Z') return FONT_ALPHA[c - 'A'];
  switch (c) {
    case '+': return GLYPH_PLUS;
    case '-': return GLYPH_MINUS;
    case '!': return GLYPH_BANG;
    case '.': return GLYPH_DOT;
    case ':': return GLYPH_COLON;
    case '?': return GLYPH_QUEST;
    case '/': return GLYPH_SLASH;
    default:  return nullptr;
  }
}
